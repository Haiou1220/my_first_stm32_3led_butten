# Keil uVision project my_first_stm32.uvprojx, settings and files
target my_first_stm32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: my_first_stm32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Code;.\STM32F10x_FWLib\inc;.\User;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HardWave
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Code
    ./Code/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group HardWave
    ./HardWave/: key.c led.c
